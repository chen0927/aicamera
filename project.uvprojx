# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: CMSIS_NN, RT_USING_LIBC, __FPU_PRESENT = 1, __RTTHREAD__, MICROPY_PY_SENSOR = 1, RT_USING_ARMLIBC, MICROPY_PY_DISPLAY = 1, NDEBUG, TF_LITE_STATIC_MEMORY, ARM_MATH_CM85, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: board\ports\wifi;packages\LVGL-v8.3.10\src\extra\widgets\spinner;rt-thread\components\net\lwip\port;packages\LVGL-v8.3.10\src\extra\widgets\calendar;board\ports\mipi_lcd;rt-thread\components\drivers\include;rt-thread\include;packages\OpenMV-v4.5.0\src\omv\common;board\ports\CMSIS-NN\Include\Internal;rt-thread\components\net\lwip\lwip-2.0.3\src\include;packages\LVGL-v8.3.10\src\draw\nxp\pxp;rt-thread\components\net\sal\include\socket;packages\LVGL-v8.3.10\src\font;board\lvgl\custom;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;rt-thread\components\libc\posix\io\epoll;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;rt-thread\components\net\sal\impl;packages\micropython-v1.13.0\port\modules;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;packages\micropython-v1.13.0\py;packages\LVGL-v8.3.10\src\extra\themes\basic;board\lvgl;packages\LVGL-v8.3.10\src\extra\themes;board\ports\tf-micro\signal\src;packages\LVGL-v8.3.10\src\extra\others;packages\LVGL-v8.3.10\src\extra\others\monkey;packages\rw007-v2.1.0;packages\LVGL-v8.3.10\src\extra\widgets\spinbox;packages\LVGL-v8.3.10\src\extra\widgets\tileview;packages\LVGL-v8.3.10\src\core;rt-thread\components\drivers\wlan;packages\OpenMV-v4.5.0\src\omv\ports\ra8;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.10\src\draw\arm2d;packages\micropython-v1.13.0;rt-thread\components\drivers\touch;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;packages\LVGL-v8.3.10\src\draw\sw;packages\LVGL-v8.3.10\env_support\rt-thread;board\ports\tf-micro\third_party\ruy;packages\LVGL-v8.3.10\src\extra\widgets\span;packages\LVGL-v8.3.10\src\extra\libs\qrcode;packages\micropython-v1.13.0\ports\renesas;packages\OpenMV-v4.5.0\src\omv;board\lvgl\generated\guider_fonts;packages\LVGL-v8.3.10\src\extra\widgets\tabview;packages\LVGL-v8.3.10\src\draw\swm341_dma2d;packages\tinyusb\lib\rt-thread;board\ports\tf-micro\third_party\gemmlowp;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;packages\OpenMV-v4.5.0\src\omv\imlib;packages\CmBacktrace-v1.4.1;packages\LVGL-v8.3.10\src\draw;packages\LVGL-v8.3.10\src\extra\widgets\menu;packages\tinyusb\src;packages\LVGL-v8.3.10\src\extra\libs\rlottie;board\ports\CMSIS-NN\Include;rt-thread\components\finsh;packages\LVGL-v8.3.10\src\extra\others\imgfont;packages\LVGL-v8.3.10\src\extra\widgets\win;rt-thread\components\libc\compilers\common\extension;packages\OpenMV-v4.5.0;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\LVGL-v8.3.10\src\extra\others\gridnav;board\lvgl\generated\guider_customer_fonts;packages\LVGL-v8.3.10\src\extra\others\fragment;board\lvgl\generated\images;board;packages\LVGL-v8.3.10\src\draw\stm32_dma2d;rt-thread\components\drivers\spi;packages\LVGL-v8.3.10\src\extra\widgets\animimg;rt-thread\components\net\sal\include;packages\LVGL-v8.3.10\src\extra\themes\default;packages\LVGL-v8.3.10\src\extra\libs\bmp;packages\OpenMV-v4.5.0\src\hal;packages\LVGL-v8.3.10\src\extra\libs\fsdrv;packages\OpenMV-v4.5.0\src\hal\cmsis\include;Applications;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\lib\libtf;rt-thread\components\drivers\include;board\ports\omv_fs;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.10\src\extra\libs\freetype;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\dfs_net;board\ports\tf-micro\third_party\kissfft;packages\OpenMV-v4.5.0\src\omv\modules;rt-thread\components\libc\posix\ipc;packages\OpenMV-v4.5.0\src\omv\boards\RA8;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\LVGL-v8.3.10\src\extra\widgets\led;packages\LVGL-v8.3.10\src\extra\layouts\grid;packages\zFTP-latest\inc;packages\LVGL-v8.3.10\src\extra\themes\mono;board\ports\tf-micro\libtf;packages\LVGL-v8.3.10\src\extra\others\msg;board\ports\scc8660;packages\LVGL-v8.3.10\src\widgets;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;packages\LVGL-v8.3.10\src;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;rt-thread\components\net\lwip-dhcpd;rt-thread\components\libc\posix\io\eventfd;board\lvgl\generated;rt-thread\components\drivers\include;libraries\HAL_Drivers\config;rt-thread\components\net\netdev\include;packages\LVGL-v8.3.10\src\extra\libs\gif;packages\LVGL-v8.3.10\src\draw\sdl;packages\LVGL-v8.3.10\src\extra\widgets\list;rt-thread\components\libc\compilers\common\extension\fcntl\octal;board\ports\tf-micro\signal\micro\kernels;packages\LVGL-v8.3.10\src\draw\renesas;packages\LVGL-v8.3.10\src\misc;packages\LVGL-v8.3.10\src\extra\others\ime;packages\LVGL-v8.3.10\src\extra;packages\LVGL-v8.3.10\src\draw\nxp\vglite;packages\LVGL-v8.3.10\src\extra\widgets\meter;packages\micropython-v1.13.0\lib\utils;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;board\ports\tf-micro\signal\src\kiss_fft_wrappers;board\ports;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\drivers\include;board\lvgl\demo;packages\rw007-v2.1.0\inc;board\ports\CMSIS-NN;packages\micropython-v1.13.0\port;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user;rt-thread\components\libc\cplusplus;packages\cst812t-latest\inc;packages\LVGL-v8.3.10\src\extra\libs;.;packages\OpenMV-v4.5.0\src\omv\sensors;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\drivers\include;board\ports\tf-micro\third_party\flatbuffers\include;rt-thread\components\drivers\include;libraries\HAL_Drivers;packages\micropython-v1.13.0\port\modules\machine;packages\OpenMV-v4.5.0\src\omv\alloc;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;packages\LVGL-v8.3.10\src\extra\widgets;packages\LVGL-v8.3.10\src\extra\libs\ffmpeg;board\ports\tf-micro;packages\micropython-v1.13.0\lib\libm_dbl;packages\LVGL-v8.3.10\src\extra\libs\sjpg;packages\LVGL-v8.3.10\src\extra\widgets\colorwheel;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;packages\LVGL-v8.3.10\src\extra\layouts;packages\LVGL-v8.3.10\src\extra\libs\png;rt-thread\components\libc\posix\io\poll;packages\LVGL-v8.3.10\src\extra\widgets\chart;packages\LVGL-v8.3.10\src\extra\widgets\msgbox;packages\LVGL-v8.3.10\src\extra\widgets\keyboard;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;packages\LVGL-v8.3.10\src\extra\widgets\imgbtn;rt-thread\components\dfs\dfs_v1\include;packages\LVGL-v8.3.10\src\extra\others\snapshot;packages\LVGL-v8.3.10\src\hal;rt-thread\components\fal\inc;packages\LVGL-v8.3.10\src\extra\layouts\flex
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group app
    Applications/: app_sd.c app_rtc.c app_autowifi.c app_ui.c app_openmv.c app_camera.c
  group app.lvgl
    board/lvgl/custom/: custom.c
    board/lvgl/generated/: events_init.c gui_guider.c setup_scr_screen0.c setup_scr_screen1.c setup_scr_screen2.c widgets_init.c
    board/lvgl/generated/guider_fonts/: lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_22.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_montserratMedium_22.c
    board/lvgl/generated/images/: _camera_alpha_130x124.c _logo_alpha_132x26.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_flash_log.c cm_backtrace.c cmb_port.c
  group CMSIS_NN
    board/ports/CMSIS-NN/Source/ConvolutionFunctions/: arm_nn_depthwise_conv_s8_core.c arm_convolve_1_x_n_s8.c arm_depthwise_conv_s4.c arm_nn_mat_mult_s8.c arm_convolve_s16.c arm_nn_mat_mult_kernel_s4_s16.c arm_convolve_1x1_s8.c arm_convolve_fast_s16.c arm_convolve_wrapper_s16.c arm_convolve_get_buffer_sizes_s16.c arm_depthwise_conv_s8_opt.c arm_nn_mat_mult_kernel_s8_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_wrapper_s16.c arm_convolve_s8.c arm_depthwise_conv_wrapper_s4.c arm_convolve_1x1_s4.c arm_convolve_s4.c arm_depthwise_conv_fast_s16.c arm_convolve_1x1_s4_fast.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_depthwise_conv_s8.c arm_transpose_conv_s8.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_transpose_conv_get_buffer_sizes_s8.c arm_depthwise_conv_wrapper_s8.c arm_convolve_get_buffer_sizes_s4.c arm_depthwise_conv_s4_opt.c arm_convolve_1x1_s8_fast.c arm_convolve_wrapper_s4.c arm_depthwise_conv_s16.c arm_convolve_get_buffer_sizes_s8.c arm_depthwise_conv_3x3_s8.c
    board/ports/CMSIS-NN/Source/FullyConnectedFunctions/: arm_fully_connected_get_buffer_sizes_s16.c arm_fully_connected_s8.c arm_fully_connected_s4.c arm_fully_connected_get_buffer_sizes_s8.c arm_vector_sum_s8.c arm_fully_connected_s16.c
    board/ports/CMSIS-NN/Source/NNSupportFunctions/: arm_nn_vec_mat_mult_t_svdf_s8.c arm_s8_to_s16_unordered_with_offset.c arm_q7_to_q15_with_offset.c arm_nn_vec_mat_mult_t_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_vec_mat_mult_t_s4.c arm_nn_mat_mul_core_4x_s8.c arm_nn_lstm_update_cell_state_s16.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nntables.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_mat_mult_nt_t_s4.c arm_nn_mat_mul_kernel_s16.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_vec_mat_mult_t_s16.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_lstm_update_output_s8_s16.c arm_nn_lstm_calculate_gate_s8_s16.c arm_nn_mat_mul_core_1x_s8.c arm_nn_vec_mat_mul_result_acc_s8.c arm_nn_lstm_step_s8_s16.c
    board/ports/CMSIS-NN/Source/ConcatenationFunctions/: arm_concatenation_s8_y.c arm_concatenation_s8_z.c arm_concatenation_s8_w.c arm_concatenation_s8_x.c
    board/ports/CMSIS-NN/Source/PoolingFunctions/: arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_s16.c arm_max_pool_s16.c arm_max_pool_s8.c arm_avgpool_get_buffer_sizes_s16.c arm_avgpool_s8.c
    board/ports/CMSIS-NN/Source/ActivationFunctions/: arm_relu6_s8.c arm_nn_activation_s16.c arm_relu_q15.c arm_relu_q7.c
    board/ports/CMSIS-NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s16_s8.c arm_elementwise_mul_s8.c
    board/ports/CMSIS-NN/Source/SoftmaxFunctions/: arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_s8.c arm_nn_softmax_common_s8.c arm_softmax_s16.c
    board/ports/CMSIS-NN/Source/LSTMFunctions/: arm_lstm_unidirectional_s8_s16.c
    board/ports/CMSIS-NN/Source/SVDFunctions/: arm_svdf_get_buffer_sizes_s8.c arm_svdf_s8.c arm_svdf_state_s16_s8.c
    board/ports/CMSIS-NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt_init.c cxx_crt.cpp
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group cst812t
    packages/cst812t-latest/: cst812t.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_pwm.c drv_rtc.c drv_sci.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal.c fal_rtt.c fal_flash.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c msh_parse.c msh_file.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group LVGL
    packages/LVGL-v8.3.10/src/font/: lv_font_montserrat_44.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_28.c lv_font_loader.c lv_font_montserrat_16.c lv_font_montserrat_12.c lv_font_fmt_txt.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_20.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_24.c lv_font_unscii_8.c lv_font_simsun_16_cjk.c lv_font_montserrat_18.c lv_font.c lv_font_unscii_16.c lv_font_montserrat_10.c lv_font_montserrat_48.c lv_font_montserrat_14.c lv_font_montserrat_46.c lv_font_montserrat_22.c lv_font_montserrat_40.c lv_font_montserrat_12_subpx.c lv_font_montserrat_36.c lv_font_montserrat_42.c lv_font_montserrat_38.c lv_font_montserrat_8.c lv_font_montserrat_26.c
    packages/LVGL-v8.3.10/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.10/src/misc/: lv_math.c lv_ll.c lv_area.c lv_txt.c lv_async.c lv_fs.c lv_bidi.c lv_gc.c lv_color.c lv_timer.c lv_utils.c lv_mem.c lv_log.c lv_templ.c lv_printf.c lv_lru.c lv_anim_timeline.c lv_style_gen.c lv_tlsf.c lv_style.c lv_anim.c lv_txt_ap.c
    packages/LVGL-v8.3.10/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_vglite_buf.c lv_draw_vglite_blend.c lv_vglite_utils.c lv_draw_vglite_line.c lv_draw_vglite.c lv_draw_vglite_rect.c
    packages/LVGL-v8.3.10/src/widgets/: lv_arc.c lv_btn.c lv_btnmatrix.c lv_switch.c lv_line.c lv_objx_templ.c lv_dropdown.c lv_table.c lv_label.c lv_textarea.c lv_slider.c lv_img.c lv_bar.c lv_roller.c lv_canvas.c lv_checkbox.c
    packages/LVGL-v8.3.10/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_rect.c lv_draw_sdl_img.c lv_draw_sdl_composite.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl.c lv_draw_sdl_utils.c lv_draw_sdl_bg.c lv_draw_sdl_layer.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c
    packages/LVGL-v8.3.10/src/draw/: lv_draw_img.c lv_img_decoder.c lv_img_cache.c lv_draw_layer.c lv_draw_triangle.c lv_draw_transform.c lv_draw.c lv_draw_label.c lv_draw_arc.c lv_draw_line.c lv_draw_rect.c lv_draw_mask.c lv_img_buf.c
    packages/LVGL-v8.3.10/src/draw/sw/: lv_draw_sw_polygon.c lv_draw_sw_line.c lv_draw_sw_transform.c lv_draw_sw_rect.c lv_draw_sw_letter.c lv_draw_sw.c lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c
    packages/LVGL-v8.3.10/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.10/src/core/: lv_obj.c lv_indev.c lv_indev_scroll.c lv_obj_class.c lv_disp.c lv_obj_pos.c lv_obj_style.c lv_group.c lv_obj_style_gen.c lv_obj_tree.c lv_event.c lv_obj_draw.c lv_obj_scroll.c lv_refr.c lv_theme.c
    packages/LVGL-v8.3.10/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.10/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.10/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.10/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.10/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.10/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.10/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.10/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.10/src/extra/: lv_extra.c
    packages/LVGL-v8.3.10/src/extra/libs/fsdrv/: lv_fs_posix.c lv_fs_win32.c lv_fs_stdio.c lv_fs_fatfs.c
    packages/LVGL-v8.3.10/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.10/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.10/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.10/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.10/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.10/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.10/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.10/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.10/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.10/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.10/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.10/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.10/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.10/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.10/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.10/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.10/src/hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
    packages/LVGL-v8.3.10/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.10/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.10/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.10/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.10/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.10/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.10/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.10/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.10/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.10/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.10/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.10/src/draw/nxp/pxp/: lv_gpu_nxp_pxp.c lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.10/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.10/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.10/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.10/src/extra/widgets/tabview/: lv_tabview.c
  group LVGL-demo
    board/lvgl/demo/: lv_demo.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c mouse_cursor_icon.c
    packages/LVGL-v8.3.10/env_support/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip-dhcpd/: dhcp_server_raw.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group micropython
    packages/micropython-v1.13.0/py/: nlrxtensa.c mpstate.c parsenum.c asmx86.c objint_mpz.c modcmath.c qstr.c scope.c objexcept.c map.c objsingleton.c vstr.c builtinimport.c objmap.c modcollections.c objrange.c opmethods.c nlraarch64.c objfun.c mpprint.c reader.c nlrpowerpc.c emitglue.c emitnxtensawin.c objslice.c persistentcode.c argcheck.c objgenerator.c emitbc.c warning.c bc.c objdict.c malloc.c objstr.c nlrmips.c formatfloat.c objnamedtuple.c emitnative.c objtuple.c stackctrl.c asmbase.c emitcommon.c objgetitemiter.c modbuiltins.c nativeglue.c sequence.c nlrthumb.c objenumerate.c objtype.c pairheap.c smallint.c obj.c objarray.c objint_longlong.c emitnthumb.c objstringio.c modgc.c vm.c objfilter.c builtinevex.c frozenmod.c objobject.c moduerrno.c builtinhelp.c objattrtuple.c parse.c nlrx86.c compile.c objint.c objpolyiter.c showbc.c asmarm.c asmxtensa.c objbool.c objlist.c emitnx64.c profile.c nlrsetjmp.c asmx64.c objproperty.c modmicropython.c pystack.c emitinlinethumb.c objboundmeth.c emitnx86.c objstrunicode.c modmath.c repl.c nlrx64.c binary.c modthread.c objzip.c objcell.c emitinlinextensa.c gc.c ringbuf.c nlr.c objmodule.c emitnxtensa.c objreversed.c mpz.c omvdummy.c runtime_utils.c emitnarm.c objclosure.c lexer.c objfloat.c modstruct.c asmthumb.c scheduler.c modarray.c modsys.c stream.c objdeque.c objset.c modio.c parsenumbase.c objcomplex.c objnone.c runtime.c unicode.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/drivers/bus/: softspi.c softqspi.c
    packages/micropython-v1.13.0/extmod/: moduhashlib.c modujson.c modonewire.c moduwebsocket.c machine_spi.c modurandom.c vfs_fat_file.c machine_pulse.c moduzlib.c modwebsocket.c vfs_reader.c moducryptolib.c modure.c vfs_posix.c moduselect.c machine_signal.c machine_i2c.c uos_dupterm.c modbtree.c machine_mem.c modubinascii.c modutimeq.c modframebuf.c modwebrepl.c moduheapq.c modussl_axtls.c moductypes.c utime_mphal.c vfs_posix_file.c vfs.c modussl_mbedtls.c vfs_fat.c vfs_fat_diskio.c virtpin.c machine_pinbase.c
    packages/micropython-v1.13.0/lib/utils/: pyexec.c sys_stdio_mphal.c printf.c mpirq.c stdout_helpers.c interrupt_char.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
  group micropython/machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_pwm.c machine_hw_spi.c machine_adc.c machine_wdt.c machine_pin.c machine_lcd.c machine_hw_i2c.c machine_uart.c modmachine.c machine_timer.c machine_rtc.c
  group micropython/modules
    packages/micropython-v1.13.0/port/modules/: modfile.c modnetwork.c modutime.c modpyb.c moduos_file.c modnetwork_wlan.c moduos.c modffi.c modrtthread.c modusocket.c modutils.c
    packages/micropython-v1.13.0/port/: mpy_main.c frozen_mpy.c mpgetcharport.c mpthreadport.c mphalport.c mpputsnport.c gccollect.c
    packages/micropython-v1.13.0/port/native/: native_module.c easyflash_module.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group micropython/ra-port
    packages/micropython-v1.13.0/ports/renesas/: tinyusb_debug.c pyb_uart.c bufhelper.c machine_led.c led.c pyb_i2c.c
  group openmv/alloc
    packages/OpenMV-v4.5.0/src/omv/alloc/: dma_alloc.c umm_malloc.c fb_alloc.c xalloc.c unaligned_memcpy.c
  group openmv/common
    packages/OpenMV-v4.5.0/src/omv/common/: array.c sensor_utils.c ringbuf.c mutex.c trace.c factoryreset.c vospi.c usbdbg.c
  group openmv/dsp
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_cos_q15.c arm_sin_f32.c arm_cos_f32.c arm_sin_q31.c arm_cos_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_sin_q15.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q15.c arm_rfft_init_q31.c
  group openmv/imlib
    packages/OpenMV-v4.5.0/src/omv/imlib/: selective_search.c rectangle.c draw.c jpeg.c filter.c hough.c haar.c kmeans.c clahe.c jpegd.c mjpeg.c template.c line.c integral_mw.c imlib.c mathop.c qrcode.c binary.c fast.c sincos_tab.c gif.c orb.c blob.c bmp.c framebuffer.c yuv.c lodepng.c apriltag.c edge.c png.c fsort.c lab_tab.c dmtx.c integral.c lbp.c eye.c agast.c pool.c hog.c zbar.c lsd.c rainbow_tab.c ppm.c qsort.c xyz_tab.c isp.c phasecorrelation.c fft.c point.c fmath.c font.c stereo.c bayer.c stats.c collections.c
  group openmv/modules
    packages/OpenMV-v4.5.0/src/omv/modules/: py_spi_display.c py_imageio.c py_helper.c py_mjpeg.c py_image.c py_omv.c py_sensor.c py_tf.c py_display.c py_clock.c py_gif.c
  group openmv/port/ra8
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: omv_lcd.c cambus.c omv_gpio.c sensor.c
  group openmv/rtt-port
    board/ports/omv_fs/: ff_wrapper.c
  group openmv/sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: hm0360.c mt9m114.c paj6100.c gc0328.c scc8660.c ov7670.c ov7690.c ov9650.c lepton.c gc2145.c frogeye2020.c ov2640.c mt9v0xx.c ov7725.c ov5640.c hm01b0.c
  group openmv/ulab
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft.c fft_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: stats.c compare.c transform.c poly.c numpy.c create.c approx.c filter.c numerical.c vector.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ndarray_properties.c ndarray_operators.c ulab.c ulab_tools.c ndarray.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray.c carray_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
  group openmv/ulab/scipy
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tensorflow
    board/ports/tf-micro/tensorflow/lite/kernels/internal/: common.cpp tensor_ctypes.cpp tensor_utils.cpp portable_tensor_utils.cpp quantization_util.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/internal/reference/: comparisons.cpp portable_tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/core/api/: flatbuffer_conversions.cpp tensor_utils.cpp error_reporter.cpp
    board/ports/tf-micro/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp
    board/ports/tf-micro/tensorflow/lite/micro/memory_planner/: linear_memory_planner.cpp greedy_memory_planner.cpp
    board/ports/tf-micro/tensorflow/lite/core/c/: common.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/: kernel_util.cpp
    board/ports/tf-micro/tensorflow/lite/schema/: schema_utils.cpp
  group tensorflow/cmsis_nn
    board/ports/tf-micro/tensorflow/lite/micro/kernels/cmsis_nn/: svdf.cpp depthwise_conv.cpp mul.cpp pooling.cpp softmax.cpp add.cpp fully_connected.cpp conv.cpp
  group tensorflow/kernels
    board/ports/tf-micro/tensorflow/lite/micro/kernels/: strided_slice_common.cpp fill.cpp leaky_relu.cpp unidirectional_sequence_lstm.cpp zeros_like.cpp maximum_minimum.cpp reduce.cpp slice.cpp svdf_common.cpp depthwise_conv_common.cpp leaky_relu_common.cpp floor_div.cpp neg.cpp space_to_batch_nd.cpp concatenation.cpp detection_postprocess.cpp kernel_util.cpp batch_matmul.cpp strided_slice.cpp pack.cpp reshape.cpp var_handle.cpp softmax_common.cpp cumsum.cpp pad.cpp div.cpp logical_common.cpp prelu_common.cpp broadcast_to.cpp conv_common.cpp if.cpp elementwise.cpp gather_nd.cpp logical.cpp reduce_common.cpp kernel_runner.cpp sub.cpp elu.cpp gather.cpp logistic.cpp reshape_common.cpp space_to_depth.cpp call_once.cpp embedding_lookup.cpp hard_swish.cpp logistic_common.cpp quantize_common.cpp split.cpp ceil.cpp l2norm.cpp pooling_common.cpp read_variable.cpp cast.cpp ethosu.cpp floor_mod.cpp log_softmax.cpp resize_nearest_neighbor.cpp split_v.cpp activations.cpp arg_min_max.cpp depth_to_space.cpp fully_connected_common.cpp mul_common.cpp quantize.cpp circular_buffer_common.cpp activations_common.cpp add_n.cpp transpose_conv.cpp hard_swish_common.cpp prelu.cpp circular_buffer.cpp exp.cpp squeeze.cpp l2_pool_2d.cpp lstm_eval_common.cpp round.cpp resize_bilinear.cpp expand_dims.cpp tanh.cpp squared_difference.cpp assign_variable.cpp dequantize.cpp micro_tensor_utils.cpp select.cpp add_common.cpp transpose.cpp unpack.cpp floor.cpp mirror_pad.cpp broadcast_args.cpp sub_common.cpp shape.cpp batch_to_space_nd.cpp while.cpp comparisons.cpp dequantize_common.cpp lstm_eval.cpp
    board/ports/tf-micro/tensorflow/lite/micro/cortex_m_generic/: micro_time.cpp debug_log.cpp
  group tensorflow/lib
    board/ports/tf-micro/libtf/: libtf.cpp libtf_builtin_models.c
  group tensorflow/micro
    board/ports/tf-micro/tensorflow/lite/micro/: micro_context.cpp micro_interpreter.cpp memory_helpers.cpp micro_allocation_info.cpp system_setup.cpp micro_op_resolver.cpp micro_interpreter_context.cpp recording_micro_allocator.cpp micro_utils.cpp test_helper_custom_ops.cpp micro_profiler.cpp fake_micro_context.cpp mock_micro_graph.cpp micro_log.cpp micro_interpreter_graph.cpp micro_allocator.cpp flatbuffer_utils.cpp test_helpers.cpp micro_resource_variable.cpp
    board/ports/tf-micro/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cpp micro_error_reporter.cpp
  group tensorflow/signal
    board/ports/tf-micro/signal/micro/kernels/: window.cpp filter_bank.cpp delay.cpp filter_bank_spectral_subtraction.cpp irfft.cpp fft_auto_scale_kernel.cpp rfft.cpp pcan.cpp overlap_add.cpp fft_auto_scale_common.cpp framer.cpp filter_bank_log.cpp filter_bank_square_root.cpp stacker.cpp energy.cpp filter_bank_square_root_common.cpp
    board/ports/tf-micro/signal/src/: filter_bank.cpp pcan_argc_fixed.cpp irfft_int32.cpp square_root_32.cpp fft_auto_scale.cpp filter_bank_square_root.cpp rfft_float.cpp log.cpp msb_32.cpp overlap_add.cpp filter_bank_log.cpp irfft_int16.cpp energy.cpp msb_64.cpp window.cpp max_abs.cpp circular_buffer.cpp filter_bank_spectral_subtraction.cpp square_root_64.cpp rfft_int16.cpp rfft_int32.cpp irfft_float.cpp
    board/ports/tf-micro/signal/src/kiss_fft_wrappers/: kiss_fft_float.cpp kiss_fft_int32.cpp kiss_fft_int16.cpp
  group TinyUSB
    board/tinyusb/: drv_tinyusb.c usb_descriptors.c
    packages/tinyusb/src/class/cdc/: cdc_device.c
    packages/tinyusb/src/common/: tusb_fifo.c
    packages/tinyusb/src/device/: usbd.c usbd_control.c
    packages/tinyusb/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c
    packages/tinyusb/src/: tusb.c
    packages/tinyusb/lib/rt-thread/: tusb_rt_thread_port.c
  group WICED
    board/ports/scc8660/: scc8660.lib
  group zFTP
    packages/zFTP-latest/src/: zFTP.c
    packages/zFTP-latest/samples/: zFTP_demo.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
